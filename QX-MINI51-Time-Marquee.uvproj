# Keil uVision project QX-MINI51-Time-Marquee.uvproj, settings and files
target Simulator (MCS-51)
  device: 8XC52 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(11059200) MODP2
  output: QX-MINI51-Time-Marquee +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: QX-MINI51-Time-Marquee.c
  group Documentation
    ./: ABSTRACT.TXT
